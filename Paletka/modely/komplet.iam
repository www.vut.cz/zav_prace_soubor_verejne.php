# Autodesk Inventor assembly: komplet
## iProperties
Created: 2010-03
Part Number: komplet
Document SubType Name: Assembly
Designer: Ondra
Author: Ondra
