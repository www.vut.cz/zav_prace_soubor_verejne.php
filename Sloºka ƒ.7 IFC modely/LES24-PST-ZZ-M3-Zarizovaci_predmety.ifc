Properties of the parts of a building model (IFC4)

# File
Description: ViewDefinition [ReferenceView_V1.2], ExchangeRequirement [Architecture], Option [Elements to export: Visible elements (on all stories)], Option [Partial Structure Display: Entire Model], Option [IFC Domain: All], Option [Structural Function: All Elements], Option [Convert Grid elements: On], Option [Convert IFC Annotations and Archicad 2D elements: Off], Option [Convert 2D symbols of Doors and Windows: Off], Option [Export geometries that Participates in Collision Detection only: On], Option [Split complex elements: Off], Option [Material Preservation: Explode where necessary], Option [IFC Model position: Survey Point and Project Origin], Option [Curtain Wall export mode: Single Element], Option [Railing export mode: Single Element], Option [Stair export mode: Single Element], Option [Properties To Export: All properties], Option [Space containment: On], Option [IFC Domain For Space Containment: All], Option [Geometry to type objects: Off], Option [Element Properties: Off], Option [Building Material Properties: Off], Option [Element Parameters: Off], Option [Component Parameters: Off], Option [IFC Base Quantities: On], Option [Door Window Parameters: On], Option [IFC Space boundaries: On], Option [Archicad Zone Categories as IFC Space classification data: Off], Option [Element Classifications: Off]
File name: C:\Users\micel\OneDrive\Dokumenty\ŠKOLA\!!4.LS!!\BAKALÁŘKA\Publikace\Nová složka\LES24-PST-ZZ-M3-Zarizovaci_predmety.ifc
Time: 2024-05-22T15:31:05
Author: Architect
Organization: Building Designer Office
Written by: DDS_IFC v3.0
Made in: IFC file generated by Graphisoft Archicad 27.0.0 CZE FULL Windows version (IFC add-on version: 3001 CZE FULL).
Authorization: The authorising person

# IfcProject, Univerzitní lezecké centrum
Description: BIM projekt - bakalářská práce

# IfcSite, Exteriér
RefLatitude: 50, 1, 18, 339575; RefLongitude: 15, 46, 11, 568244; RefElevation: 221783 mm
Qto_SiteBaseQuantities - GrossPerimeter: 0 mm; GrossArea: 3562 m2

# IfcBuilding, Univerzitní lezecké centrum
Qto_BuildingBaseQuantities - GrossFloorArea: 0 m2

# IfcBuildingStorey (4)
In: Univerzitní lezecké centrum
Qto_BuildingStoreyBaseQuantities - GrossFloorArea: 0 m2
Name | Elevation (mm) | NetHeight (mm) = GrossHeight (mm)
1.PP | -3350 | 3350
1.NP | 0 | 3200
2.NP | 3200 | 3200
4.NP | 9600 | 3200

# IfcSanitaryTerminal: Pisoár 24 (3)
Description: Výška osazení 750 mm, bílý porcelán, splachování pomocí čidla nad pisoárem
Reference - Referenční výrobek: https://www.siko.cz/pisoar-se-senzorem-jika-golem-zadni-odpad-h8430700004831/p/4307.0.000.483.1
Pset_ManufacturerOccurrence - AcquisitionDate: DD.MM.RRRR
Name | In
2 x OV14 | 1.PP
OV14 | 2.NP

# IfcSanitaryTerminal: Sprchová baterie 27 (14)
Description: Závěsná sprchová baterie s kruhovou hlavicí s kloubovým nastavitelným sklonem toku, ovládací baterie osazena ve výšce 1200 mm, provedení chrom
Reference - Referenční výrobek: https://eshop.perfecto.cz/sprchova-hlavice-jazz-zavesna-200-mm-kruhova-chrom-cerny
Pset_ElementShading - Color: Chrom
Pset_ManufacturerOccurrence - AcquisitionDate: DD.MM.RRRR
Name | In
10 x OV16 | 1.PP
4 x OV16 | 2.NP

# IfcSanitaryTerminal: Umyvadlo 27 (3)
Pset_ManufacturerOccurrence - AcquisitionDate: DD.MM.RRRR
Name | In | Description | Refereční výrobek
OV19 | 1.PP | Umyvadlo pro invalidy 580x680 s vybráním pro lepší manipulaci invalidy, páková baterie s prodlouženou rukojetí v provedení chrom | Reference - Referenční výrobek: https://www.siko.cz/bezbarierove-umyvadlo-jika-mio-65x55-cm-bez-otvoru-pro-baterii-h8137140001091/p/1371.4.000.109.1
OV18 | 1.NP | Malé umývatko na samostatná WC, obdélníkové 350x450 mm, chromová páková baterie | https://www.hornbach.cz/p/umyvatko-jika-lyra-40-cm/10238621/
OV18 | 4.NP | Malé umývatko na samostatná WC, obdélníkové 350x450 mm, chromová páková baterie | https://www.hornbach.cz/p/umyvatko-jika-lyra-40-cm/10238621/

# IfcSanitaryTerminal: Umyvadlový pult 27 (4)
Reference - Referenční výrobek: https://eshop.perfecto.cz/sanitarni-keramika/umyvadla/pod-desku/umyvadlo-simple-480-x-390-x-185-pod-desku
Pset_ManufacturerOccurrence - AcquisitionDate: DD.MM.RRRR
Name | In | Description
2 x OV17 | 1.PP | Zdvojené oválné umyvadlo 460x330 mm osazené v desce tl. 25 mm o velikosti 500x920, deska bílá lesklá, umyvadlo z bílého porcelánu, baterie na čidlo v provedení chrom
2 x OV15 | 2.NP | Oválné umyvadlo 460x330 mm osazené v desce tl. 25 mm o velikosti 500x920, deska bílá lesklá, umyvadlo z bílého porcelánu, baterie na čidlo v provedení chrom

# IfcSanitaryTerminal: Výlevka 24, OV21
In: 1.PP
Description: Výlevka pro úklidové činnosti, závěsná baterie s dlouhým hrdlem, volně stojící na integrovaných nohách
Reference - Referenční výrobek: https://ggmgastro.cz/cs-cz-czk/vylevka-hhwbb4040?gad_source=1&gclid=CjwKCAjwupGyBhBBEiwA0UcqaAyOWoBKkOPuw0Hh_OB2YwB257EMsbYIZTNDJKp2WREfzXgWx7GDaxoC3u4QAvD_BwE
Pset_ManufacturerOccurrence - AcquisitionDate: DD.MM.RRRR

# IfcSanitaryTerminal: WC 27 (9)
Description: Závěsná WC mísa hranatá se zaoblenými rohy, splachování ovládáno ovládacím tlačítkem osazeným ve výšce 1200 mm, modul geberit vrámci ZTI, bílý porcelán s plastovým záchodovým prkénkem
Reference - Referenční výrobek: https://www.siko.cz/wc-zavesne-jika-deep-zadni-odpad-h8206100000001/p/2061.0.000.000.1
Pset_ManufacturerOccurrence - AcquisitionDate: DD.MM.RRRR
Name | In
4 x OV13 | 1.PP
3 x OV13 | 2.NP
OV13 | 1.NP
OV13 | 4.NP

# IfcSanitaryTerminal: WC pro invalidy 24, OV20
In: 1.PP
Description: WC soustava pro invalidy, pevné madlo s držákem na toaletní papír, druhé madlo sklopné, závěsná WC mísa hranatá se zaoblenými rohy, splachování pro invalidy na šňůrce, modul geberit vrámci ZTI, bílý porcelán s plastovým zách
Reference - Referenční výrobek 1 - wc: https://www.siko.cz/wc-zavesne-jika-deep-zadni-odpad-h8206100000001/p/2061.0.000.000.1; Referenční výrobek 2 - madlo: https://www.domadlo.cz/madla/sklopne-madlo-k-wc-cerne-premium/?variantId=6732&gad_source=1&gclid=Cj0KCQjwjLGyBhCYARIsAPqTz19XfGuzF5elPqTnrAIbElLZ7wnr_MVMisr3O8MhNryhpfX53IZmZeUaAhHgEALw_wcB
Pset_ManufacturerOccurrence - AcquisitionDate: DD.MM.RRRR
