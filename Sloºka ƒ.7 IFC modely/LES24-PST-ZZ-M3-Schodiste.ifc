Properties of the parts of a building model (IFC4)

# File
Description: ViewDefinition [Design_Transfer_View, QuantityTakeOffAddOnView, SpaceBoundary2ndLevelAddOnView], ExchangeRequirement [Architecture], Option [Elements to export: Visible elements (on all stories)], Option [Partial Structure Display: Entire Model], Option [IFC Domain: All], Option [Structural Function: All Elements], Option [Convert Grid elements: On], Option [Convert IFC Annotations and Archicad 2D elements: Off], Option [Convert 2D symbols of Doors and Windows: Off], Option [Export geometries that Participates in Collision Detection only: Off], Option [Split complex elements: Off], Option [Material Preservation: Explode where necessary], Option [Elements in Solid Element Operations: Extruded/revolved], Option [Elements with junctions: Extruded/revolved without junctions], Option [IFC Model position: Survey Point and Project Origin], Option [Curtain Wall export mode: Container Element], Option [Railing export mode: Single Element], Option [Stair export mode: Container Element], Option [Properties To Export: All properties], Option [Space containment: On], Option [IFC Domain For Space Containment: All], Option [Geometry to type objects: Off], Option [Element Properties: Off], Option [Building Material Properties: Off], Option [Element Parameters: Off], Option [Component Parameters: Off], Option [IFC Base Quantities: On], Option [Door Window Parameters: On], Option [IFC Space boundaries: On], Option [Archicad Zone Categories as IFC Space classification data: Off], Option [Element Classifications: Off]
File name: C:\Users\micel\OneDrive\Dokumenty\ŠKOLA\!!4.LS!!\BAKALÁŘKA\Publikace\Nová složka\LES24-PST-ZZ-M3-Schodiste.ifc
Time: 2024-05-22T15:31:45
Author: Architect
Organization: Building Designer Office
Written by: DDS_IFC v3.0
Made in: IFC file generated by Graphisoft Archicad 27.0.0 CZE FULL Windows version (IFC add-on version: 3001 CZE FULL).
Authorization: The authorising person

# IfcProject, Univerzitní lezecké centrum
Description: BIM projekt - bakalářská práce

# IfcSite, Exteriér
RefLatitude: 50, 1, 18, 339575; RefLongitude: 15, 46, 11, 568244; RefElevation: 221783 mm
Qto_SiteBaseQuantities - GrossPerimeter: 0 mm; GrossArea: 3562 m2

# IfcBuilding, Univerzitní lezecké centrum
Qto_BuildingBaseQuantities - GrossFloorArea: 0 m2

# IfcBuildingStorey (4)
In: Univerzitní lezecké centrum
Qto_BuildingStoreyBaseQuantities - GrossFloorArea: 0 m2
Name | Elevation (mm) | NetHeight (mm) = GrossHeight (mm)
1.NP | 0 | 3200
1.PP | -3350 | 3350
2.NP | 3200 | 3200
3.NP | 6400 | 3200

# IfcMember: IfcMember (12)
Material: Beton vyztužený
Pset_ManufacturerOccurrence - AcquisitionDate: DD.MM.RRRR
Pset_MemberCommon - Status: EXISTING
Name | In | GrossVolume (m3) = NetVolume (m3)
SR032 | 1.PP | 1.0985
SM015 | 1.PP | 0.620716
SR033 | 1.PP | 0.939104
SR030 | 1.NP | 1.14209
SM014 | 1.NP | 0.566864
SR031 | 1.NP | 0.949577
SR030 | 2.NP | 1.1571
SM014 | 2.NP | 0.566864
SR031 | 2.NP | 0.949577
SR030 | 3.NP | 1.14209
SM014 | 3.NP | 0.566864
SR031 | 3.NP | 0.949577

# IfcStair: Typ schodiště (4)
Description: Železobetonové schodiště, vyztuženo dle SKŘ
Parametry - Pevnosntní třída: C25/30
Pset_StairCommon - NumberOfRiser: 20; NumberOfTreads: 20; RequiredHeadroom: 2200 mm; Status: EXISTING
Pset_ManufacturerOccurrence - AcquisitionDate: DD.MM.RRRR
Name | In | RiserHeight (mm) | WalkingLineOffset (mm)
SCH02 | 1.NP | 160 | 7682.58 | Group: Beton
SCH01 | 1.PP | 167.5 | 7671.06
SCH03 | 2.NP | 160 | 7682.58
SCH04 | 3.NP | 160 | 7682.58
